<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_Occupancy_Sensor.ewp</path>
    </project>
    <batchBuild />
</workspace>
